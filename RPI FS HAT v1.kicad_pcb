# Repository jlangulo/RaspberryHat

## KiCad design RPI FS HAT v1.kicad_pcb

Board: 2 copper layers, 27.7 x 20.3 mm, 9 parts (0 on the bottom side), 7 nets.

Parts:
D1, D2: LED; LED_0805_2012Metric
J1: Raspberry_Pi_2_3; PinHeader_2x08_P2.54mm_Vertical
R1, R2: 10kΩ; R_0805_2012Metric
R3, R4: 330Ω; R_0805_2012Metric
SW1: SW_DPST; SW_PUSHBUTTON_PTH
U1: DHT22; PinHeader_1x04_P2.54mm_Vertical

Connections:
/3V3: J1.1, R2.1, R4.1, SW1.1, U1.1
/buttton_input: J1.8, R1.1, SW1.2
GND: D1.1, D2.1, J1.6, J1.9, R1.2, U1.4
unnamed: D1.2, R3.2
unnamed: D2.2, R4.2
unnamed: J1.7, R3.1
unnamed: J1.11, R2.2, U1.2

## Commit log

2020-05-17 Added All Files
